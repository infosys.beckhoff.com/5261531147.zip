TYPE E_AnalysisIDs :
(
	(* analysis chain *)
	eID_Source := 1,
	eID_PowerSpectrum,
	eID_PowerCepstrum,
	eID_Sink_Spec,
	eID_Sink_Ceps
	
) UDINT;
END_TYPE
